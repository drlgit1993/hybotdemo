# Keil uVision project hybotdemo.uvprojx, settings and files
target hybotdemo (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: hybotdemo_V100 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F405xx,USE_USB_OTG_FS,USE_SD_CARD_FATFS
  c include: ../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../test/inc;../app/inc;../bsp/inc;..\bsp\inc;..\fml\inc;..\tool\inc;..\FatFs\inc;..\USB\USB_APP\inc;..\USB\STM32_USB_Device_Library\Class\MSC\Inc;..\USB\STM32_USB_Device_Library\Core\Inc;..\update\inc;..\FreeRTOS\port\RVDS\ARM_CM4F;..\FreeRTOS\include;..\cm_backtrace
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: ..\output\hybotdemo_V100.sct
  group app
    ../app/src/: main.c stm32f4xx_hal_msp.c stm32f4xx_it.c USART_Task.c app_mem.c disk_Task.c Time_Task.c gnss_Task.c air724_Task.c ESP32_Task.c lsm6dsl_task.c iap.c ublox_cfg.c
    ../app/inc/: FreeRTOSConfig.h
  group bsp
    ../bsp/src/: bsp_gpio.c bsp_sd_sdio.c bsp_usart1.c bsp_usart2.c bsp_uart4.c bsp_timer.c bsp_led.c bsp_iwdg.c bsp_flash.c bsp_disk_fatfs.c bsp_i2c.c bsp_rng.c bsp_usart6.c bsp_spi.c ak09918.c bsp_adc.c LPS22HB.c bsp_power.c lsm6dsl_reg.c bmi160.c bsp_bmi160.c
  group tool
    ../tool/src/: tool.c que.c crc16.c
  group fatfs
    ../FatFs/src/: ffsystem.c ff.c diskio.c
    ../FatFs/option/: ffunicode.c
  group test
    ../test/src/: bsp_sdio_test.c bsp_fatfs_test.c bsp_uart_test.c ntrip_test.c sdm_test.c
  group startup
    ./: startup_stm32f405xx.s
  group CMSIS
    ../Drivers/CMSIS/: system_stm32f4xx.c
  group STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_ll_sdmmc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_mmc.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_sd.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_spi.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c
  group FreeRTOS
    ../FreeRTOS/src/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../FreeRTOS/port/MemMang/: heap_4.c
    ../FreeRTOS/port/RVDS/ARM_CM4F/: port.c
  group cm_backtrace
    ../cm_backtrace/: cm_backtrace.c cmb_cfg.h cmb_def.h
    ../cm_backtrace/fault_handler/keil/: cmb_fault.S
software components: CMSIS:CORE 5.4.0
